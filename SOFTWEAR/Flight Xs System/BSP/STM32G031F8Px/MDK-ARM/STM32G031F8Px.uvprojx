# Keil uVision project STM32G031F8Px.uvprojx, settings and files
target STM32G031F8Px (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G031F8Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32G031F8Px +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G031xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../bsp_stm32g031f8px;../../../SystemCore/Config;../../../SystemCore/Control;../../../SystemCore/Hardware;../../../SystemCore/Math
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g031xx.s
  group Application/User/Core
    ../bsp_stm32g031f8px/: bsp_stm32g031f8px.c
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Config 参数
    ../../../SystemCore/Config/: fmuConfig.h pidConfig.h
  group Control 姿态控制
    ../../../SystemCore/Control/: FollowLine.c height_control.c Init.c kernel.c pos_ctrl.c program_ctrl.c remote.c SDK.c speed_estimator.c control.c
    ../../../SystemCore/: Mymain.c
  group Hardwear 硬件设备
    ../../../SystemCore/Hardware/: battery.c hardware.c LED.c motor.c mpu6050.c power.c SPL06.c timer_drv.c
  group Math 数学相关
    ../../../SystemCore/Math/: filter.c imu.c kalman.c myMath.c pid.c queue.c
software components: CMSIS:CORE 4.3.0
